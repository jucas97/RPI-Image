FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0001-kernel-src-Specify-the-gpio-lines-name-property.patch \
"
